options:
  parameters:
    generate_options: qt_gui
    id: SoundLoopback
    output_language: python
    title: SoundLoopback
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}

connections:
- [audio_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
