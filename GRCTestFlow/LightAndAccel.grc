options:
  parameters:
    generate_options: qt_gui
    id: LightAndAccel
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_1
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,3,1
    label1: AccelX
    label2: AccelY
    label3: AccelZ
    max: '10'
    min: '-10'
    name: Accel
    nconnections: '3'
    type: float
    unit1: m/s^2
    unit2: m/s^2
    unit3: m/s^2
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,1
    label1: LightSensor
    name: LightSensor
    type: float
  states: {}

connections:
- [audio_source_0, '0', qtgui_number_sink_1, '0']
- [audio_source_1, '0', qtgui_number_sink_0, '0']
- [audio_source_1, '0', qtgui_number_sink_0, '1']
- [audio_source_1, '0', qtgui_number_sink_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
