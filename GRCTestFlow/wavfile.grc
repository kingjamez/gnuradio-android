options:
  parameters:
    author: adi
    generate_options: qt_gui
    id: wavfile
    output_language: python
    title: wavfile
  states: {}

blocks:
- name: py_file
  id: variable
  parameters:
    value: root+"PinkPanther30.wav"
  states: {}
- name: py_uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: root
  id: variable
  parameters:
    value: '"/home/adi/Downloads/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '22050'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: py_file
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
