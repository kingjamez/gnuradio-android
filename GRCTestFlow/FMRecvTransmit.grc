options:
  parameters:
    generate_options: qt_gui
    id: FMRecvTransmit
    output_language: python
    title: FMRecvTransmit
  states: {}

blocks:
- name: LO
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,0,1,1)
    label: LO Frequency
    outputmsgname: value
    showports: 'False'
    start: '70000000'
    step: '1'
    stop: '6000000000'
    value: '462562500'
    widget: counter
  states: {}
- name: PTT
  id: variable_qtgui_push_button
  parameters:
    gui_hint: (0,1,2,1)
    label: PTT
    pressed: '0'
    released: '89'
    type: real
    value: '89'
  states: {}
- name: audio_in_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: audio_out_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: quad_rate_rx
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: quad_rate_tx
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: sample_rate_rx
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: sample_rate_tx
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '"ip:192.168.0.200"'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: volume
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.1'
    widget: slider
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_out_rate
    max_dev: 5e3
    quad_rate: quad_rate_rx
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_in_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: quad_rate_tx
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_out_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_in_rate
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: not PTT
    type: float
  states: {}
- name: blocks_copy_1
  id: blocks_copy
  parameters:
    enabled: PTT
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: PTT
    bandwidth: '200000'
    buffer_size: '16384'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: LO
    samplerate: sample_rate_tx
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: 16*1024
    filter_source: '''Auto'''
    frequency: LO
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate_rx
    type: fc32
    uri: uri
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: (int)(sample_rate_rx / (quad_rate_rx))
    gain: '1'
    samp_rate: 'sample_rate_rx '
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: quad_rate_tx
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: sample_rate_rx
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,1,1,1
    name: RF In
    type: complex
  states: {}
- name: qtgui_sink_x_2
  id: qtgui_sink_x
  parameters:
    bw: '576000'
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,1
    name: RF Out
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Audio
    size: '1024'
    srate: audio_out_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(sample_rate_tx/quad_rate_tx)
    type: ccc
  states: {}

connections:
- [analog_nbfm_rx_0, '0', dc_blocker_xx_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_1, '0']
- [audio_source_0, '0', blocks_copy_0, '0']
- [blocks_copy_0, '0', analog_nbfm_tx_0, '0']
- [blocks_copy_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [iio_pluto_source_0, '0', blocks_copy_1, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
