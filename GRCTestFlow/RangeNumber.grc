options:
  parameters:
    author: adi
    generate_options: qt_gui
    id: RangeNumber
    output_language: python
    title: RangeNumber
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '-100'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: variable_qtgui_range_0
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '-100'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
